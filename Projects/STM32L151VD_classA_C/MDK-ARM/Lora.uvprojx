# Keil uVision project Lora.uvprojx, settings and files
target TFB_App (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32L152VD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFB_App +hex
  AfterMake: hexmate TFB_Boot.hex .\Build\TFB_App.hex -OTFB_BL_App_V1.10.hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L152xD, USE_BAND_868, DEF_APP
  c misc: --C99
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\inc\Drivers;..\..\..\Drivers\sx1272;..\..\..\Drivers\TI_ADS1248\inc;..\..\..\Middlewares\Third_Party\Lora\Crypto;..\..\..\Middlewares\Third_Party\Lora\Mac;..\..\..\Middlewares\Third_Party\Lora\Phy;..\..\..\Middlewares\Third_Party\Lora\Utilities;..\..\..\Middlewares\Third_Party\Lora\Core;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\Third_Party\FatFs\src;..\inc\App;..\inc\Disk;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x5b000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Build\TFB_App.sct
  group System
    ../src/Drivers/: system_stm32l1xx.c
    ./: startup_stm32l152xd.s
  group Drivers/HAL
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_sd.c stm32l1xx_ll_sdmmc.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c
  group Drivers/HW
    ../src/Drivers/: hw.c hw_adc.c hw_gpio.c hw_ios.c hw_msp.c hw_rtc.c hw_spi.c hw_uart.c stm32l1xx_hal_msp.c stm32l1xx_it.c hw_iwdg.c hw_sdio.c hw_i2c.c hw_dac.c hw_tim.c
  group Drivers/sx1272
    ../../../Drivers/sx1272/: sx1272.c sx1272_board.c
  group Drivers/TI_ADS1248
    ../../../Drivers/TI_ADS1248/src/: ads1248.c ads1248_board.c
  group Middlewares/Lora
    ../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
    ../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../Middlewares/Third_Party/Lora/Utilities/: utilities.c
    ../../../Middlewares/Third_Party/Lora/Core/: lora.c
  group Middlewares/USB_Device_Library
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FatFs
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Projects/App
    ../src/App/: bsp.c debug.c loraModem.c low_power.c meas.c rtcApp.c timeServer.c vcom.c app.c log.c com.c config.c BT.c Si705x.c RS485.c RTD.c Thermocouple.c
    ../src/: main.c
  group Projects/Disk
    ../src/Disk/: Disk.c eeprom.c fatfs.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c user_diskio.c usbd_cdc_if.c bsp_driver_sd.c sd_diskio.c
  group Doc
    ./: Doc.txt
target TFB_App_DB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152VD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: as above
  output: TFB_App_DB +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L152xD, USE_BAND_868, DEF_APP, DEBUG
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x5b000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Build\TFB_App.sct
